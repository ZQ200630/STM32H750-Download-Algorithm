# Keil uVision project STM32H750XBH6_ArtPi_QSPI_W25Q64JV.uvprojx, settings and files
target stm32h750 (6160000::V6.16::ARMCLANG)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H750XBH6_ArtPi_W25Q64JV
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: .\W25Q64JV
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32H750XBHx/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./RTE/Device/STM32H750XBHx/STCubeGenerated/Inc/: stm32h7xx_it.h
  group System File
    ./RTE/Device/STM32H750XBHx/: system_stm32h7xx.c
  group QUADSPI Memory
    ./W25Q64JV/: quadspi.c
software components: CMSIS:CORE 5.5.0, Device:STM32Cube HAL:Common 1.9.0, Device:STM32Cube HAL:Cortex 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:MDMA 1.9.0, Device:STM32Cube HAL:PWR 1.9.0, Device:STM32Cube HAL:QSPI 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:Startup 1.9.0
